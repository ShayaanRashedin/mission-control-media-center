# Keil uVision project MediaCenter.uvprojx, settings and files
target MediaCenter (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MediaCenter +hex
  c flags: Optim=1
  c include: .
  asm include: .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group Source Files
    ./: usbuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c adcuser.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group Media Center
    ./: main.c media.c GLCD_SPI_LPC1700.c games.c
